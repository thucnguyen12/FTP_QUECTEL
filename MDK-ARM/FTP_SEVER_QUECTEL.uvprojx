# Keil uVision project FTP_SEVER_QUECTEL.uvprojx, settings and files
target FTP_SEVER_QUECTEL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L083RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: FTP_SEVER_QUECTEL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L083xx
  c include: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\gsm; ..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l083xx.s
  group Application/User/Core
    ../Core/Inc/: ringBuffer.c ringBuffer.h
    ../gsm/: app_debug.h app_debug.c SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group gsm_fuction
    ../gsm/: hw_polling_task.h
    ./: hw_polling_task.c gsm_data_layer.h gsm_data_layer.c gsm_ultilities.c gsm.h gsm_ultilities.h
software components: CMSIS:CORE 4.3.0
